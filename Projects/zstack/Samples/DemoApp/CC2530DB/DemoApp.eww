<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DemoApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DemoApp</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>DemoApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>DemoApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>DemoApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


